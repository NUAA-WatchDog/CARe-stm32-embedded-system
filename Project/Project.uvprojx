# Keil uVision project Project.uvprojx, settings and files
target STM32_Data_proj (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: UART-485 +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\CMSIS\DeviceSupport\Startup;..\Libraries\STM32F10x_StdPeriph_Driver_V3.5\inc;..\Libraries\STM32F10x_StdPeriph_Driver_V3.5\src;..\User\Main;..\User\Delay;..\User\Led;..\User\Lcd
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User/Main
    ../User/Main/: main.c stm32f10x_it.c hw_config.c
    ../Libraries/STM32F10x_StdPeriph_Driver_v3.5/src/: stm32f10x_adc.c
  group Libraries/StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver_V3.5/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
    ../Libraries/STM32F10x_StdPeriph_Driver_v3.5/src/: stm32f10x_exti.c stm32f10x_tim.c
  group Libraries/CMSIS
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/DeviceSupport/Startup/: startup_stm32f10x_cl.s
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
  group Lcd
    ../User/Lcd/: lcd.c
  group Delay
    ../User/Delay/: delay.c
  group Doc
    ../Doc/: information.txt
  group HX711
    ../User/HX711/: HX711.c
  group ds18b20
    ./: ds18b20.c
  group MAX30102
    ../User/MAX30102/: bsp_i2c_gpio.c max_30102.c
